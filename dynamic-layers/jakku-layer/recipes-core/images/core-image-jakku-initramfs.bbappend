FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

include generic.inc
