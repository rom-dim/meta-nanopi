TOOLCHAIN_HOST_TASK += "nativesdk-sam-ba"
